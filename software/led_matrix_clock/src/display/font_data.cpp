// 自动生成文件 —— 由 tools/gen_font.py 生成，请勿手改
// 字模格式：行式，每行 1 字节，bit0 = 最左列（见布局稿 §1）
#include "display/font_data.h"

namespace {

// 大数字 4x7：'0'..'9'，每字符 7 行（七段样式）
const uint8_t kBig4x7[10][7] = {
    {0x0F, 0x09, 0x09, 0x00, 0x09, 0x09, 0x0F},  // '0'
    {0x00, 0x08, 0x08, 0x00, 0x08, 0x08, 0x00},  // '1'
    {0x0F, 0x08, 0x08, 0x0F, 0x01, 0x01, 0x0F},  // '2'
    {0x0F, 0x08, 0x08, 0x0F, 0x08, 0x08, 0x0F},  // '3'
    {0x00, 0x09, 0x09, 0x0F, 0x08, 0x08, 0x00},  // '4'
    {0x0F, 0x01, 0x01, 0x0F, 0x08, 0x08, 0x0F},  // '5'
    {0x0F, 0x01, 0x01, 0x0F, 0x09, 0x09, 0x0F},  // '6'
    {0x0F, 0x08, 0x08, 0x00, 0x08, 0x08, 0x00},  // '7'
    {0x0F, 0x09, 0x09, 0x0F, 0x09, 0x09, 0x0F},  // '8'
    {0x0F, 0x09, 0x09, 0x0F, 0x08, 0x08, 0x0F},  // '9'
};

// 小字 3x5：{码值, 5 行}（七段数字 + 自绘符号）
struct SmallGlyph {
  uint8_t code;
  uint8_t rows[5];
};
const SmallGlyph kSmall3x5[] = {
    {0x30, {0x07, 0x05, 0x00, 0x05, 0x07}},  // '0'
    {0x31, {0x00, 0x04, 0x00, 0x04, 0x00}},  // '1'
    {0x32, {0x07, 0x04, 0x07, 0x01, 0x07}},  // '2'
    {0x33, {0x07, 0x04, 0x07, 0x04, 0x07}},  // '3'
    {0x34, {0x00, 0x05, 0x07, 0x04, 0x00}},  // '4'
    {0x35, {0x07, 0x01, 0x07, 0x04, 0x07}},  // '5'
    {0x36, {0x07, 0x01, 0x07, 0x05, 0x07}},  // '6'
    {0x37, {0x07, 0x04, 0x00, 0x04, 0x00}},  // '7'
    {0x38, {0x07, 0x05, 0x07, 0x05, 0x07}},  // '8'
    {0x39, {0x07, 0x05, 0x07, 0x04, 0x07}},  // '9'
    {0x25, {0x05, 0x04, 0x02, 0x01, 0x05}},  // '%'
    {0x2D, {0x00, 0x00, 0x07, 0x00, 0x00}},  // '-'
    {0x41, {0x07, 0x05, 0x07, 0x05, 0x00}},  // 'A'
    {0x50, {0x07, 0x05, 0x07, 0x01, 0x00}},  // 'P'
    {0x80, {0x05, 0x00, 0x07, 0x01, 0x07}},  // '°C'
};

}  // namespace

const uint8_t* bigDigit4x7(char ch) {
  if (ch < '0' || ch > '9') {
    return nullptr;
  }
  return kBig4x7[ch - '0'];
}

const uint8_t* smallGlyph3x5(char ch) {
  for (const SmallGlyph& g : kSmall3x5) {
    if (g.code == static_cast<uint8_t>(ch)) {
      return g.rows;
    }
  }
  return nullptr;
}
